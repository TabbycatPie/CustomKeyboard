# Keil uVision project CH552E.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CH552E-RX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\usar
  group usar
    ./usar/: DataFlash.C Debug.C main.c CH552.INC
    ./: HIDdevice.c HIDdevice.h
