# Keil uVision project CH552E.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH551 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0xFF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: DIY +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\usar;.\usar\DataFlash;.\usar\USB
  group usar
    ./usar/: Debug.C main.c CH552.INC
  group app
    ./usar/DataFlash/: DataFlash.C
    ./usar/USB/: usb.c
