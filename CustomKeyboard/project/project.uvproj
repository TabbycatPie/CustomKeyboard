# Keil uVision project project.uvproj, settings and files
target RF_rec (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CH552G +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\Public;..\usar\DataFlash;..\usar\USB
  group user
    ./: main.c
  group bsp
    ../bsp/: GPIO.C SPI.C si24R1.c
  group public
    ../Public/: Debug.C
    ./: global.h
  group usar
    ../usar/DataFlash/: DataFlash.C DataFlash.H
    ../usar/USB/: usb.c usb.h
