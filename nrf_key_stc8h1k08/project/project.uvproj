# Keil uVision project project.uvproj, settings and files
target nrf_key_stc8h1k08 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: STC8 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\user
  group user
    ./: STARTUP.A51
    ../user/: main.c
  group bsp
    ../bsp/: user_driver.c si24R1.c
